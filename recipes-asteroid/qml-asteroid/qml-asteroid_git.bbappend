FILESEXTRAPATHS_prepend_sturgeon := "${THISDIR}/qml-asteroid:"
SRC_URI_append_sturgeon = " file://machine.conf"
